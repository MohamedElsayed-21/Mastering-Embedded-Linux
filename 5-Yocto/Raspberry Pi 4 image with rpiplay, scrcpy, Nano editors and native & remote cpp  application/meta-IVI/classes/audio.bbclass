IMAGE_INSTALL:append = " pavucontrol  pulseaudio-module-dbus-protocol pulseaudio-server pulseaudio-module-loopback \ 
			pulseaudio-module-bluetooth-discover  pulseaudio-module-bluetooth-policy  pulseaudio-module-bluez5-device \ 
			pulseaudio-module-bluez5-discover  \
			alsa-ucm-conf  alsa-topology-conf  alsa-state alsa-lib alsa-tools alsa-utils alsa-plugins"




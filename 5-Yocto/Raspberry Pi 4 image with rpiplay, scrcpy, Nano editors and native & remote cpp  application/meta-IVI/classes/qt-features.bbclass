IMAGE_INSTALL:append =" qttools qtbase-examples qtquickcontrols qtbase-plugins  qtquickcontrols2 \ 
                  qtgraphicaleffects qtmultimedia qtserialbus qtquicktimeline qtvirtualkeyboard"

IMAGE_INSTALL:append = " net-tools iproute2 iputils libsocketcan i2c-tools hostapd iptables "

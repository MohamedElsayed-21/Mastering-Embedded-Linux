SYSROOT_DIRS:append="${prefix}/src"